require chromium-ozone.inc

SRC_URI[md5sum] = "5b9b3c359392071c0a491e9ebaa939f4"
SRC_URI[sha256sum] = "e8df3150386729ddcb4971636627e54815ad447be5f122201e310f5bb0bcc362"

LIC_FILES_CHKSUM += "\
  file://${S}/third_party/ffmpeg/CREDITS.chromium;md5=3adeb0fd8df4d2f0d81a7e4db49e4a37 \
  file://${S}/third_party/libsrtp/LICENSE;md5=2909fcf6f09ffff8430463d91c08c4e1\
  file://${S}/third_party/yasm/source/patched-yasm/COPYING;md5=a12d8903508fb6bfd49d8d82c6170dd9 \
"
