require chromium-lge.inc

SRC_URI[md5sum] = "59357e9c21befb6bd73264f7fdc41cd1"
SRC_URI[sha256sum] = "e45c5528bf4b2bd5fcd8670e28c1d129779990b6e9d5927baf143942930bbef8"

LIC_FILES_CHKSUM += "\
  file://${S}/third_party/ffmpeg/CREDITS.chromium;md5=3adeb0fd8df4d2f0d81a7e4db49e4a37 \
  file://${S}/third_party/libsrtp/LICENSE;md5=2909fcf6f09ffff8430463d91c08c4e1\
  file://${S}/third_party/yasm/source/patched-yasm/COPYING;md5=a12d8903508fb6bfd49d8d82c6170dd9 \
"
