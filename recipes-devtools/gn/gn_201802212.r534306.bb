require gn.inc

S = "${WORKDIR}/chromium-ozone-wayland-dev-66.0.3340.0.r534306.igalia.1"

SRC_URI = "https://tmp.igalia.com/chromium-tarballs/chromium-ozone-wayland-dev-66.0.3340.0.r534306.igalia.1.tar.xz"

SRC_URI[md5sum] = "f418f4df5261cfdcf39e7901924876a2"
SRC_URI[sha256sum] = "2679c89f09394bf2df86a090958a599303562746ce9296b07c263eb16f8d9148"
