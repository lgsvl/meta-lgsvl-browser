require gn.inc
require recipes-browser/chromium/chromium-upstream-tarball.inc

SRC_URI[md5sum] = "7b49792021b7e9bb6a0f0acc35ebe78d"
SRC_URI[sha256sum] = "e1addc3378500d61584c37dee9bac99ae3c30ff5ebb24c6ca5a571b465a29d34"
